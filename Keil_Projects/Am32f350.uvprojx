# Keil uVision project Am32f350.uvprojx, settings and files
target REF_F350_STANDALONE (6120000::V6.12::.\ARMCLANG)
  device: GD32F350K8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.4.0
  cpu: IRAM(0x20000000-0x20001FFF)IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: AM32_REF_F350_STANDALONE +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F350,REF_F350,VECT_TAB_OFFSET=0
  c include: ..\Mcu\f350\Drivers\CMSIS\Core\Include;..\Mcu\f350\Drivers\CMSIS\Include;..\Mcu\f350\Drivers\GD32F3x0_standard_peripheral\Include;..\mcu\f350\Inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\f350\Am32_standalone.sct
  group Src
    ../Src/: dshot.c functions.c main.c signal.c sounds.c firmwareversion.c kiss_telemetry.c
  group cmis
    ../Mcu/f350/Drivers/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group Startup
    ../Mcu/f350/Startup/mdk/: startup_gd32f3x0.s
  group f350
    ../Mcu/f350/Src/: ADC.c comparator.c eeprom.c gd32f3x0_it.c IO.c peripherals.c phaseouts.c serial_telemetry.c system_gd32f3x0.c systick.c
software components: CMSIS:CORE 5.2.0
