# Keil uVision project Am32e235.uvprojx, settings and files
target REF_E235_STANDALONE (6120000::V6.12::.\ARMCLANG)
  device: GD32E235K8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: AM32_REF_E235_STANDALONE +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E235,REF_E235,VECT_TAB_OFFSET=0
  c include: ..\Mcu\e235\Drivers\CMSIS\Core\Include;..\Mcu\e235\Drivers\CMSIS\Include;..\Mcu\e235\Drivers\GD32E23x_standard_peripheral\Include;..\Mcu\e235\Inc;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\e235\Am32_standalone.sct
  group Src
    ../Src/: dshot.c functions.c main.c signal.c sounds.c firmwareversion.c kiss_telemetry.c
  group cmsis
    ../Mcu/e235/Drivers/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c
  group Startup
    ../Mcu/e235/Startup/mdk/: startup_gd32e23x.s
  group e235
    ../Mcu/e235/Src/: ADC.c comparator.c eeprom.c gd32e23x_it.c IO.c peripherals.c phaseouts.c serial_telemetry.c system_gd32e23x.c systick.c
software components: CMSIS:CORE 5.2.0
